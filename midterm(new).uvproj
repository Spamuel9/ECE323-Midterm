# Keil uVision project midterm(new).uvproj, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: LPC1114/202 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: midterm(new)
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s basic_keypad_config.s basic_LCD_config.s BusyWait.s configure_clock.s convert_to_values.s Disable_port0_interrupt.s division_time.s En_port0_interrupt.s get_next_key_input.s handle_flag.s Init_TMR16B1.s Init_TMR16B0.s Init_TMR32B0.s Init_TMR32B1.s Keypad_init.s keyrelease.s keyvalue.s LCD_command.s LCD_init.s main.s PIOINT0_IRQHandler.s print_string.s printchar.s TIMER32_0_IRQHandler.s TIMER32_1_IRQHandler.s TMR32B0CAP_INT.s TMR32B0MR3_Interrupt.s commonlyusedvalues.inc everyvalue.inc prescale_search.s handle_the_input.s enter_tx.s enter_the_channel.s update_the_memory.s search_the_memory.s printing_decimal.s clearing_flag.s channelconfig.s all_channels.s
